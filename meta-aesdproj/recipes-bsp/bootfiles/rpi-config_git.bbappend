VC4GRAPHICS = "0"
RPI_EXTRA_CONFIG = "\n#ENABLE Video Camera\nstart_x=1\n#Enable GPU Mem\ngpu_mem=512\n#HDMI\nhdmi_mode=1\n\nhdmi_group=16\n#Enable audio\ndtparam=audio=on\n#enable vcm graphics\ndtoverlay=vc4-kms-v3d\n"
